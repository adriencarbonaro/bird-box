## sdkconfig.defaults
```kconfig
# default UART baudrate so monitor prints at 115200
CONFIG_ESP_CONSOLE_UART_BAUDRATE=115200
```
